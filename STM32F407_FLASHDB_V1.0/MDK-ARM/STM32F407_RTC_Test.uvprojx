# Keil uVision project STM32F407_RTC_Test.uvprojx, settings and files
target STM32F407_RTC_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407_RTC_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP\DWT;../BSP/SFUD/inc;../BSP/SFUD/app;..\BSP\FAL\inc;..\BSP\FLASHDB\inc;..\BSP\FLASHDB\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP/SFUD
    ../BSP/SFUD/app/: sfud_app.c
    ../BSP/SFUD/src/: sfud.c sfud_port.c sfud_sfdp.c
  group BSP/FAL
    ../BSP/FAL/src/: fal.c fal_flash.c fal_flash_sfud_port.c fal_partition.c fal_rtt.c
  group BSP/FLASHDB
    ../BSP/FLASHDB/app/: flashdb_app.c
    ../BSP/FLASHDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group BSP/DWT
    ../BSP/DWT/: dwt.c
software components: CMSIS:CORE 4.3.0
